# Keil uVision project STM32F103.uvprojx, settings and files
target STM32F103 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CORE;..\FWLIB\inc;..\SYSTEM;..\USER;..\uIP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../CORE/: core_cm3.c stm32f10x_it.c stm32f10x_conf.h system_stm32f10x.c startup_stm32f10x_hd.s
  group USER
    ../USER/: main.c led.c spi.c enc28j60.c debug.c timer.c tasks.c uip_task.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_tim.c
  group uIP
    ../uIP/: psock.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c tapdev.c uip_appcall.c uip-conf.h
